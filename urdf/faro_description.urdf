Commit message: gazebo configruation

File: urdf/faro_description.urdf (robot description, URDF)
Before this commit: robot faro_description, 5 links, 4 joints
Links:
- removed link Base2_Link
- removed link Esfera_Link
Joints:
- removed joint Base2_Joint
- removed joint Esfera_Joint
